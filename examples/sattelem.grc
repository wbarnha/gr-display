options:
  parameters:
    author: wbarnha
    generate_options: qt_gui
    id: telem
    output_language: python
    title: Telemetry Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/wbarnha/gr-satellites/satellite-recordings/itasat1.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {state: bypassed}
- name: satellites_satellite_decoder_0_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/ITASAT_1.yml
    name: str(sat_type)
    norad: '100000'
    samp_rate: samp_rate
  states: {}
- name: show_text_0
  id: show_text
  parameters: {}
  states: {}

connections:
- [blocks_wavfile_source_0, '0', low_pass_filter_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', satellites_satellite_decoder_0_0, '0']
- [satellites_satellite_decoder_0_0, out, show_text_0, disp_pdu]

metadata:
  file_format: 1
