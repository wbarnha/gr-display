options:
  parameters:
    category: Custom
    generate_options: hb_qt_gui
    id: AptUI
    output_language: python
  states: {}

blocks:
- name: Force
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1
    label: Force Display
    label0: Automatic start
    label1: Force start
    num_opts: '2'
    option1: '1'
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: Ifgain
  id: variable_qtgui_range
  parameters:
    gui_hint: Rx@0:0,2,1,1
    min_len: '80'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '59'
    value: '15'
    widget: counter
  states: {}
- name: Lna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: Rx@0:0,3,1,1
    label0: 'Off'
    label1: 'On'
    num_opts: '2'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: Mixergain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: Rx@0:0,4,1,1
    label0: 'Off'
    label1: 'On'
    num_opts: '2'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: RxFrequency
  id: variable_qtgui_range
  parameters:
    gui_hint: Rx@0:0,1,1,1
    label: Set Frequency Offset
    min_len: '130'
    orient: Qt.Horizontal
    start: '-50000'
    step: '1000'
    stop: '0'
    value: '-8000'
    widget: counter
  states: {}
- name: StartRecord
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0
    label: Start Recording
    label0: Stop
    label1: Start
    num_opts: '2'
    option1: '0'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: sat
  id: variable_qtgui_chooser
  parameters:
    gui_hint: Rx@0:0,0,1,1
    label0: Noaa15
    label1: Noaa17
    label2: Noaa18
    label3: Noaa19
    num_opts: '4'
    option1: '137500'
    option2: '137912'
    option3: '137100'
    type: int
    value: '137620'
  states: {}
- name: Rx
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,5,6
    label0: Spectrum and Control
    label1: Image
    num_tabs: '2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: RxFrequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: Force
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '30'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1./25500.
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'False'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '30000'
    init: '0'
    low: '20000'
  states: {}
- name: blocks_threshold_ff_1_0
  id: blocks_threshold_ff
  parameters:
    high: '0.9'
    init: '0'
    low: '-1'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /tmp/Noaa.wav
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: decodeApt_0
  id: decodeApt
  parameters:
    gain: '255'
    samp_rate_in: samp_rate
  states: {}
- name: fcdproplus_fcdproplus_1
  id: fcdproplus_fcdproplus
  parameters:
    devicename: ''
    freq: (sat-20)
    if_gain: int(Ifgain)
    lnaswitch: Lna
    mixergainswitch: Mixergain
    ppm: '0'
    unit: '1000'
  states: {state: disabled}
- name: fir_filter_xxx_0_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (-14,-14,-14,-14,-14,-14,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,-14)
    type: fff
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: Rx@0
    label1: ''
    label2: ''
    name: QT GUI Plot
    nconnections: '2'
    size: '2080'
    srate: samp_rate/10
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: Rx@0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    gui_hint: Rx@1
    imageheight: '1400'
    imagewidth: '2080'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_threshold_ff_1_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_delay_0, '0', show_image_0, '0']
- [blocks_float_to_char_0, '0', show_image_0, '1']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', decodeApt_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_complex_to_float_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_threshold_ff_1_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_1_0, '0', qtgui_time_sink_x_0, '1']
- [decodeApt_0, '0', blocks_delay_0, '0']
- [decodeApt_0, '1', fir_filter_xxx_0_2, '0']
- [fcdproplus_fcdproplus_1, '0', blocks_multiply_xx_0, '0']
- [fir_filter_xxx_0_2, '0', blocks_multiply_const_vxx_0, '0']
- [fir_filter_xxx_0_2, '0', blocks_threshold_ff_0_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
